# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  AfterMake: D:\MDK_keil5\ARM\ARMCLANG\bin\fromelf.exe
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\AD;..\HARDWARE\DHT11;..\HARDWARE\ESP8266;..\HARDWARE\Timer;..\HARDWARE\SIM800L;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\SGP30;..\HARDWARE\EXIT;..\HARDWARE\STMFLASH;..\HARDWARE\Usart;..\SYSTEM\adc;..\HARDWARE\ADC;..\HARDWARE\control;..\HARDWARE\DS18B20;..\HARDWARE\DS1302;..\HARDWARE\HX711;..\HARDWARE\SU_03T;..\HARDWARE\Flash;..\HARDWARE\HC-SR04;..\HARDWARE\HC-SR505;..\HARDWARE\HW;..\HARDWARE\MyRTC;..\HARDWARE\MQ2;..\HARDWARE\Soil;..\HARDWARE\IO_Sensor;..\HARDWARE\OLED_new;..\HARDWARE\BL0942;..\HARDWARE\UART;..\HARDWARE\AS608;..\HARDWARE\Ring_Buf;..\HARDWARE\BUTTON4_4;..\HARDWARE\RC522;..\HARDWARE\rtc;..\HARDWARE\MFRC522;..\Utils;..\Utils\Ring_Buf;..\Utils\List;..\Driver\IO_Sensor;..\Driver\OLED_new;..\Driver\UART;..\Driver;..\HARDWARE\motor;..\HARDWARE\TCS3472;..\HARDWARE\VL53L0X\core\inc;..\HARDWARE\VL53L0X\platform\inc;..\HARDWARE\VL53L0X\demo;..\HARDWARE\VL53L0X\demo;..\HARDWARE\E4G;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\HARDWARE\BH1750;..\HARDWARE\PM2.5;..\Driver\PWM;..\HARDWARE\MLX90614;..\DEV\OLED_new;..\DEV\SG90;..\HARDWARE\R60ABD1;..\DEV\AS608;..\HARDWARE\GPS;..\HARDWARE\MAX30102;..\Utils\filter-c;..\HARDWARE\Step_motor;..\HARDWARE\YFS401;..\Driver\IO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Utils
    ../Utils/List/: embedded_list.c list_save.c
    ../Utils/Ring_Buf/: ring_buf.c
    ../Utils/: utility.c
  group DEV
    ../DEV/OLED_new/: ssd1306.c ssd1306_fonts.c
    ../DEV/SG90/: sg_90.c
    ../DEV/DS18B20/: ds18b20_dev.c
  group Driver
    ../Driver/UART/: usart_driver.c
    ../Driver/PWM/: pwm_driver.c
    ../Driver/ONE_WIRE/: onewire_bus.c
    ../Driver/SOFT_I2C/: soft_i2c_master.c
    ../Driver/IO/: AI.c DI.c DO.c
  group HARDWARE
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/KEY/: Key.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/BUTTON4_4/: button4_4.c
    ../HARDWARE/SU_03T/: su_03t.c
    ../HARDWARE/HC-SR04/: hc.c
    ../HARDWARE/MAX30102/: algorithm.c xiic.c
    ../HARDWARE/OLED/: oled.c
    ../CONNECT/: ESP8266.lib
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/adc/: adcx.c
